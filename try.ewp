# IAR project try.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430fn.h
  General.OGChipSelectMenu: MSP430F2274 MSP430F2274
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: MRFI_CC2500
  ICC430.newCCIncludePaths: C:\Users\Sayo\Desktop\rf2500-wireless\drivers\bsp\boards\EZ430RF; C:\Users\Sayo\Desktop\rf2500-wireless\drivers\bsp\drivers; C:\Users\Sayo\Desktop\rf2500-wireless\drivers\mrfi; C:\Users\Sayo\Desktop\rf2500-wireless\drivers\bsp
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F2274.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
  group Application
    ./: main.c
  group Components/bsp
    ../iar-try/drivers/bsp/: bsp.c bsp.h bsp_macros.h
  group Components/mrfi
    ../iar-try/drivers/mrfi/: mrfi.c mrfi.h mrfi_defs.h
